# IAR project spi_self_loopback_multi_client_sam_9x60_ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_9x60_ek_iar; ..\src\packs\SAM9X60_DFP; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app_client1.h app_client2.h app_monitor.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h user.h configuration.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/bsp
    ../src/config/sam_9x60_ek_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/xdmac
    ../src/config/sam_9x60_ek_iar/peripheral/xdmac/: plib_xdmac_common.h plib_xdmac.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/flexcom/spi/master
    ../src/config/sam_9x60_ek_iar/peripheral/flexcom/spi/master/: plib_flexcom4_spi_master.h plib_flexcom_spi_master_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver
    ../src/config/sam_9x60_ek_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/spi
    ../src/config/sam_9x60_ek_iar/driver/spi/: drv_spi.h drv_spi_definitions.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system
    ../src/config/sam_9x60_ek_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/int
    ../src/config/sam_9x60_ek_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/ports
    ../src/config/sam_9x60_ek_iar/system/ports/: sys_ports.h sys_ports_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/cache
    ../src/config/sam_9x60_ek_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/dma
    ../src/config/sam_9x60_ek_iar/system/dma/: sys_dma.h sys_dma_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/debug
    ../src/config/sam_9x60_ek_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/osal
    ../src/config/sam_9x60_ek_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/instance
    ../src/packs/SAM9X60_DFP/instance/: adc.h aes.h aic.h bsc.h can0.h can1.h classd.h dbgu.h emac0.h emac1.h flexcom0.h flexcom1.h flexcom10.h flexcom11.h flexcom12.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h flexcom8.h flexcom9.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pioa.h piob.h pioc.h piod.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc0.h sdmmc1.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc0.h tc1.h tdes.h trng.h udphs.h uhphs_ehci.h uhphs_ohci.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Source Files
    ../src/: main.c app_client1.c app_client2.c app_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: initialization.c interrupts.c cstartup.s vectortrap.s tasks.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/bsp
    ../src/config/sam_9x60_ek_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/stdio
    ../src/config/sam_9x60_ek_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/xdmac
    ../src/config/sam_9x60_ek_iar/peripheral/xdmac/: plib_xdmac.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/flexcom/spi/master
    ../src/config/sam_9x60_ek_iar/peripheral/flexcom/spi/master/: plib_flexcom4_spi_master.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/driver/spi
    ../src/config/sam_9x60_ek_iar/driver/spi/src/: drv_spi.c drv_spi_local.h
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/int
    ../src/config/sam_9x60_ek_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/cache
    ../src/config/sam_9x60_ek_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/dma
    ../src/config/sam_9x60_ek_iar/system/dma/: sys_dma.c
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_iar/: ddram.icf
